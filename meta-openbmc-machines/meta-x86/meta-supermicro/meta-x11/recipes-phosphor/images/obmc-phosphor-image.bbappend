OBMC_IMAGE_EXTRA_INSTALL_append_supermicro-x11 = " x11-powerctrl"
