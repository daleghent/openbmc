OBMC_IMAGE_EXTRA_INSTALL_append = " x11-powerctrl"
